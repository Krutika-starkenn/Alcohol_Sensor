# Keil uVision project Project.uvproj, settings and files
target VTS + DE (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AB_01_00_D01.hex +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: VECT_TAB_FLASH
  c include: ..\..\project;..\Include;..\STM_Library\INC;..\Include;..\Hardware_Abstraction_Layer;..\RVMDK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application_Layer
    ../Application_Layer/: main.c Alcohol_Detection_Algorithm.c LED_Buzzer_Handle.c
  group Hardware_Layer
    ../Hardware_Abstraction_Layer/: CAN_Configuration.c InitStm32.c HAL_ADC.c HAL_I2C.c HAL_SPI.c Pressure_Sensor_XGPG6857D.c Alcohol_Sensor.c
  group Start_Up
    ../Startup/: cortexm3_macro.s stm32f10x_vector.s
  group STM_Library
    ../STM_Library/SRC/: stm32f10x_adc.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_systick.c
  group Communication_Layer
    ../Hardware_Abstraction_Layer/: uart.c
